# Keil uVision project harmful_gas_detector.uvprojx, settings and files
target harmful_gas_detector (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: harmful_gas_detector +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL
  c include: .\CMSIS\CoreSupport;.\CMSIS\DeviceSupport;.\STM32F10x_StdPeriph_Driver\inc;.\USER
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./CMSIS/DeviceSupport/startup/: startup_stm32f10x_cl.s
  group CMSIS
    ./CMSIS/CoreSupport/: core_cm3.c
  group STM32F10x_StdPeriph_Driver
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ./USER/: gs_api.c gs_bsp.c gs_global_para.c gs_harmful_gas_detector.c main.c stm32f10x_it.c system_stm32f10x.c
